# IAR project project5.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  A430.AUserIncludes: $TOOLKIT_DIR$\inc\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430C111.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: Main.s43
    Debug/Obj/: Shifts.r43
