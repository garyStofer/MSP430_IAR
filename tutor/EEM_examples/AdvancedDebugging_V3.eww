<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\example_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\example_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\example_3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\example_4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\example_5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\example_6.ewp</path>
  </project>
  <batchBuild/>
</workspace>


