# IAR project example_5.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 80
  General.GStackSize: 80
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F169.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AdvancedDebugging5.c
