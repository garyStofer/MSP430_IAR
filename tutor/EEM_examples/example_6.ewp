# IAR project example_6.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 80
  General.GStackSize: 300
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F169.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AdvancedDebugging6.c
