# IAR project Backup of project5.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 80
  General.GStackSize: 80
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430C111.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: Main.s43
    Debug/Obj/: Shifts.r43
