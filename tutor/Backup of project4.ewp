# IAR project Backup of project4.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 80
  General.GStackSize: 80
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  group (top)
    ./: Interrupt.c Utilities.c
